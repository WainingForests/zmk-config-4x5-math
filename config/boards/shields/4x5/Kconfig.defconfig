## config/boards/shields/Key-Pad-4x5/Kconfig.defconfig
```kconfig
if SHIELD_KEY-PAD-4X5

config ZMK_KEYBOARD_NAME
    default "Key-Pad-4x5"

endif
```
